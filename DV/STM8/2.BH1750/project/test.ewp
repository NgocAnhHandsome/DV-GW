# IAR project test.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\library; ..\user
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: test.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Header
    ../user/: bh1750.h DELAY.h i2c.h uart.h
  group library
    ../library/: STM8CONFIG.h stm8s.h stm8s_conf.h stm8s_it.c stm8s_it.h
  group user
    ../user/: bh1750.c i2c.c main.c uart.c
