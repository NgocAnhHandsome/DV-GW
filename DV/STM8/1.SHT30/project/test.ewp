# IAR project test.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\library; ..\user
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: test.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Header
    ../user/: DELAY.h device_command.h i2c.h ringbuffer.h sys.h uart.h
  group library
    ../user/: GPIO.h
    ../library/: STM8CONFIG.h stm8s.h stm8s_conf.h stm8s_it.c stm8s_it.h
  group user
    ../user/: device_command.c GPIO.c i2c.c main.c ringbuffer.c sht30.c sys.c uart.c
